# Keil uVision project jc.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: jc +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c include: ..\CMSIS;..\Library\inc;..\User;..\User\hardware\rc;..\User\APP;..\User\hardware\delay;..\User\hardware\timer;..\User\hardware\can1;..\User\hardware\adc;..\User\hardware\JY901
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../CMSIS/: startup_stm32f40xx.s
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c task.c
  group Hardware
    ../User/hardware/rc/: rc.c
    ../User/hardware/delay/: delay.c
    ../User/hardware/timer/: timer.c
    ../User/hardware/can1/: can1.c
    ../User/hardware/adc/: adc.c
    ../User/hardware/JY901/: JY901.c
  group APP
    ../User/APP/: sbus.c robomodule.c
